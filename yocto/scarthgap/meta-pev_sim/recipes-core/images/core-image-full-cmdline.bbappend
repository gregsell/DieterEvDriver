IMAGE_INSTALL:append = " \
    kernel-module-cfg80211 \
    kernel-module-brcmutil \
    kernel-module-brcmfmac \
    kernel-module-brcmfmac-wcc \
    linux-firmware-rpidistro-bcm43455 \
    pev-sim-network \
"
